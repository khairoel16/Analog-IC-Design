v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pmoscs.sym} 280 -320 0 0 {name=x1}
C {nmosds.sym} 280 -220 0 0 {name=x2}
C {nmoscs.sym} 710 -320 2 0 {name=x3}
C {pmoscs2.sym} 710 -220 2 0 {name=x4}
C {devices/lab_pin.sym} 430 -350 2 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 560 -350 0 0 {name=p3 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 430 -330 2 0 {name=p4 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 560 -190 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 430 -290 2 0 {name=p6 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 430 -200 2 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 430 -310 2 0 {name=p8 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 430 -240 2 0 {name=p2 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 430 -220 2 0 {name=p9 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 560 -310 0 0 {name=p11 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 560 -290 0 0 {name=p12 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 560 -250 0 0 {name=p13 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 560 -230 0 0 {name=p14 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 560 -210 0 0 {name=p15 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 860 -190 2 0 {name=p16 sig_type=std_logic lab=VIP}
C {devices/lab_pin.sym} 860 -210 0 1 {name=p17 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} 70 -380 0 0 {name=p18 lab=VDD}
C {devices/iopin.sym} 70 -340 0 0 {name=p19 lab=GND}
C {devices/iopin.sym} 70 -300 0 0 {name=p20 lab=VIN}
C {devices/iopin.sym} 70 -260 0 0 {name=p21 lab=VIP}
C {devices/iopin.sym} 70 -220 0 0 {name=p22 lab=OUT}
C {devices/iopin.sym} 70 -180 0 0 {name=p23 lab=RS}
C {devices/lab_pin.sym} 560 -330 0 0 {name=p10 sig_type=std_logic lab=RS}
